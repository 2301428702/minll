# IAR project IIC_OLED.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\IAR_Project\IIC_OLED\STM8S_StdPeriph_Driver\inc; D:\IAR_Project\IIC_OLED\APP; D:\IAR_Project\IIC_OLED\STM8S_StdPeriph_Driver\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: IIC_OLED.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group APP
    APP/: AT24C02.c codetab.h main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group STM8S_Lib
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c stm8s_wwdg.c
